# Keil uVision project i2ctest.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: NANO130KE3BN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.7
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: i2ctest
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c myi2c.c mylcd.c
software components: CMSIS:CORE 4.1.0, Device:Driver:CLK 3.01.000, Device:Driver:GPIO 3.01.000, Device:Driver:I2C 3.01.000, Device:Driver:SYS 3.01.000, Device:Driver:Timer 3.01.000, Device:Driver:UART 3.01.000, Device:Startup 3.01.000
